Commit message: resolved the errors

File: src/manipulator_v1/manipulator_description/arm/urdf/robarm.urdf (robot description, URDF)
Before this commit: robot arm, 5 links, 4 joints
Links:
- link base_cylinder: mass 0.36165 -> 100.36165
