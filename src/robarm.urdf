Commit message: moveit pose goal planning

File: src/robarm.urdf (robot description, URDF)
Before this commit: robot arm, 5 links, 4 joints
Links:
- added link world
Joints:
- added joint fixed: type fixed, parent world, child base_cylinder
